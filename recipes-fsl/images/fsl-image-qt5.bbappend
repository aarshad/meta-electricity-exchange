IMAGE_INSTALL += " \
    ppp \
    apt \
    gnupg \
"
